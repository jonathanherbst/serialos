inherit devicetree

COMPATIBLE_MACHINE = "beagle-serialos"

SRC_URI = " \
    file://serialos-bbb.dts \
"