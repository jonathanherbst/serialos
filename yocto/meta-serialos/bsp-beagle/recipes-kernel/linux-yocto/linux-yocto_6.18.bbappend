COMPATIBLE_MACHINE:beagle-serialos = "beagle-serialos"

KMACHINE:beagle-serialos = "beaglebone"