PACKAGECONFIG:remove = "python"