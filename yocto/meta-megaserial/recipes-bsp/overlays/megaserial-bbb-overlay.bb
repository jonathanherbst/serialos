inherit devicetree

COMPATIBLE_MACHINE = "beagle-megaserial"

SRC_URI = " \
    file://megaserial-bbb.dts \
"